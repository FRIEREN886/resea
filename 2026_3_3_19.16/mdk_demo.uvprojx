# Keil uVision project mdk_demo.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.4.5.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: mdk_demo
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\main;.\bms
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group main  code
    ./main/: BQ76920_REG.h circular_queue.c circular_queue.h FSP_UART.c FSP_UART.h BSP_IIC_EEPROM.c BSP_IIC_EEPROM.h BSP_BQ76920_I2C.c BSP_BQ76920_I2C.h BSP_WIFI.c BSP_WIFI.h BQ76920_REG.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group bms
    ./bms/: BMS_APP.c BMS_APP.h
software components: Flex Software:RA Configuration 1.0.0
